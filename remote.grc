options:
  parameters:
    author: nix
    generate_options: no_gui
    id: remote
    output_language: python
    title: Remote SDR Control
  states: {}

blocks:
- name: control_port
  id: variable
  parameters:
    value: '"6970"'
  states: {}
- name: control_protocol
  id: variable
  parameters:
    value: '"tcp"'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.1.217"'
  states: {}
- name: iq_port
  id: variable
  parameters:
    value: '"6969"'
  states: {}
- name: iq_protocol
  id: variable
  parameters:
    value: '"tcp"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3200000'
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: frequency
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: frequency
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: iq_protocol + "://" + ip_address + ":" + iq_port
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: control_protocol + "://" + ip_address + ":" + control_port
    bind: 'True'
    timeout: '100'
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', zeromq_pub_sink_0, '0']
- [zeromq_sub_msg_source_0, out, blocks_msgpair_to_var_0, inpair]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
