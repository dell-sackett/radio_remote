options:
  parameters:
    author: nix
    generate_options: qt_gui
    id: local
    output_language: python
    title: Local SDR Controller
  states: {}

blocks:
- name: control_port
  id: variable
  parameters:
    value: '"6970"'
  states: {}
- name: control_protocol
  id: variable
  parameters:
    value: '"tcp"'
  states: {}
- name: fft_size
  id: variable_qtgui_chooser
  parameters:
    label: FFT
    label0: '"1024"'
    label1: '"2048"'
    label2: '"4096"'
    label3: '"8192"'
    label4: '"16384"'
    num_opts: '5'
    option0: '1024'
    option1: '2048'
    option2: '4096'
    option3: '8192'
    option4: '16384'
    type: int
    value: '2048'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '0'
    step: '1'
    stop: '2000000000'
    value: '100000000'
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.1.217"'
  states: {}
- name: iq_port
  id: variable
  parameters:
    value: '"6969"'
  states: {}
- name: iq_protocol
  id: variable
  parameters:
    value: '"tcp"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3200000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: frequency
    target: frequency
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: frequency
    fftsize: fft_size
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: fft_size
    type: complex
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: control_protocol + "://" + ip_address + ":" + control_port
    bind: 'False'
    timeout: '100'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: iq_protocol + "://" + ip_address + ":" + iq_port
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_var_to_msg_0, msgout, zeromq_pub_msg_sink_0, in]
- [zeromq_sub_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
